# Keil uVision project IIC-EEPROM.uvprojx, settings and files
target IIC-EEPROM (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: IIC-EEPROM +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\User\I2C;..\User\LED;..\User\USART;..\User\FLASH;..\User\sram;..\User\fonts;..\User\lcd;..\User\MPU6050\driver\eMPL;..\User\MPU6050\driver\include;..\User\MPU6050\driver\stm32L;..\User\MPU6050\eMPL-hal;..\User\MPU6050\mllite;..\User\MPU6050\mpl;..\User\MPU6050;..\User\bmp;..\User\FatFs;..\User\KEY;..\User\sdio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../User/I2C/: bsp_i2c_ee.c
    ../User/USART/: bsp_usart.c
    ../User/LED/: bsp_led.c
    ../User/fonts/: fonts.c
    ../User/lcd/: bsp_ili9341_lcd.c
    ../User/FLASH/: bsp_spi_flash.c
    ../User/sram/: bsp_sram.c
    ../User/MPU6050/: bsp_mpu_exti.c
    ../User/KEY/: bsp_key.c
  group BMP
    ../User/bmp/: bsp_bmp.c
    ../User/FatFs/: diskio.c ff.c ffunicode.c ff_gen_drv.c
    ../User/sdio/: bsp_sdio_app.c bsp_sdio_sdcard.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_spi.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_sd.c stm32f1xx_ll_sdmmc.c
  group MPU_eMPL
    ../User/MPU6050/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../User/MPU6050/driver/stm32L/: log_stm32.c
    ../User/MPU6050/eMPL-hal/: eMPL_outputs.c
  group MPU_mllite
    ../User/MPU6050/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group MPU_mpl
    ../User/MPU6050/mpl/: libmpllib.lib
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
